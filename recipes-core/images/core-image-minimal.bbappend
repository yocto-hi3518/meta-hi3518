IMAGE_INSTALL += " himpp himpp-dev packagegroup-core-tools-debug python3-himpp-cffi "
IMAGE_FSTYPES = " tar.gz squashfs "

IMAGE_FEATURES += " ssh-server-dropbear "
