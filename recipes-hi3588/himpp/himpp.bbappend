FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-CFFI-ifdefs.patch file://0002-sample_venc-remove-extra-vbs.patch"

